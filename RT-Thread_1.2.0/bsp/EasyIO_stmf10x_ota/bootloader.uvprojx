# Keil uVision project bootloader.uvprojx, settings and files
target BOOTLOADER (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: INSTALL.bat
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,EASYIO_SIM800C_BRD
  c include: .;..\..\components\CMSIS\Include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\init;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\STM32F10x_StdPeriph_Driver\inc;..\easyio_core;drivers;..\..\components\net\lwip\src\include;..\..\components\net\lwip;..\..\components\net\lwip\src;..\..\components\net\lwip\src\arch\include;..\..\components\net\lwip\src\include\ipv4;..\..\components\net\lwip\src\include\netif;..\easyio_core\nmealib\include;.\drivers\extdrv;.\applications
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group easyio_core
    ../easyio_core/: app_ev.c app_timer.c common.h
  group Drivers
    drivers/: board.c stm32f10x_it.c
    ./drivers/: bootloader_usart.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c
  group Components
    ../../components/init/: components.c
  group MY_STD_FUNC
    ../easyio_core/my_stdc_func/: my_stdc_func.c debugl.c
  group MD5
    ../easyio_core/MD5/: md5sum.c
  group README
    ./: readme.txt
  group ExtDrv
    ./drivers/extdrv/: flash_opt.c led.c watch_dog.c gpio.c w25q16.c
  group Application
    ./applications/: application.c startup.c flash_config.c bootloader_main.c ota.c spiflash_config.c
    ../easyio_core/json/: cJSON.c
