# Keil uVision project CoreLibrary.uvprojx, settings and files
target CoreLibrary (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EasyCORE +hex (library)
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,EASYIO_SIM800C_BRD,ENABLE_OTA
  c include: .;..\..\components\CMSIS\Include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\init;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\STM32F10x_StdPeriph_Driver\inc;..\easyio_core;drivers;..\..\components\net\lwip\src\include;..\..\components\net\lwip;..\..\components\net\lwip\src;..\..\components\net\lwip\src\arch\include;..\..\components\net\lwip\src\include\ipv4;..\..\components\net\lwip\src\include\netif;..\easyio_core\nmealib\include;.\drivers\extdrv;.\applications
  memory RVCT4: ROM 0x8018000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Lwip_PPP
    ../../components/net/lwip/src/api/: api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c api_lib.c
    ../../components/net/lwip/src/arch/: sys_arch.c
    ../../components/net/lwip/src/core/: def.c dns.c init.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c memp.c
    ../../components/net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/net/lwip/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c randm.c vj.c
    ../../components/net/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ../../components/net/lwip/src/netif/: etharp.c slipif.c
  group XMPP
    ../easyio_core/XMPP/: xmpp.c xmpp_helper.c
  group CMUX
    ../easyio_core/gsmmux/: buffer.c gsm0710.c easyio_cmux.c
