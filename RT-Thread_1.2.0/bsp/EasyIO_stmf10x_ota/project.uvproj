# Keil uVision project project.uvproj, settings and files
target rtthread-stm32-ISP (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32 +hex
  AfterMake: fromelf.exe --bin -o./output/rtthread.bin ./build/rtthread-stm32.axf
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,EASYIO_BOARD_1,xENABLE_OTA
  c include: .;..\..\components\CMSIS\Include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\init;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\STM32F10x_StdPeriph_Driver\inc;..\easyio_core;drivers;..\..\components\net\lwip\src\include;..\..\components\net\lwip;..\..\components\net\lwip\src;..\..\components\net\lwip\src\arch\include;..\..\components\net\lwip\src\include\ipv4;..\..\components\net\lwip\src\include\netif;..\easyio_core\nmealib\include;.\drivers\extdrv
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group easyio_core
    ../easyio_core/: modem_serial.c at_cmd.c global_env.c app_ev.c ublox_gps.c lwip_raw_api_tcp_template.c xmpp_tcp.c serial_srv.c xmpp_msg_queue.c app_timer.c lowpower.c common.h ota_http_tcp.c isp_http_tcp.c
  group Drivers
    drivers/: board.c stm32f10x_it.c usart.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c
  group Components
    ../../components/init/: components.c
  group Lwip_PPP
    ../../components/net/lwip/src/api/: api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c api_lib.c
    ../../components/net/lwip/src/arch/: sys_arch.c
    ../../components/net/lwip/src/core/: def.c dns.c init.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c memp.c
    ../../components/net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/net/lwip/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c randm.c vj.c
    ../../components/net/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ../../components/net/lwip/src/netif/: etharp.c slipif.c
  group XMPP
    ../easyio_core/XMPP/: xmpp.c xmpp_helper.c
  group XML
    ../easyio_core/XML/: ezxml.c
  group BASE64
    ../easyio_core/BASE64/: cbase64.c
  group MY_STD_FUNC
    ../easyio_core/my_stdc_func/: my_stdc_func.c
  group nmealib
    ../easyio_core/nmealib/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c tok.c time.c
  group SHA1
    ../easyio_core/SHA1/: sha1.c shatest.c
  group CMUX
    ../easyio_core/gsmmux/: buffer.c gsm0710.c easyio_cmux.c
  group MD5
    ../easyio_core/MD5/: md5sum.c
  group README
    ./: readme.txt
  group ExtDrv
    ./drivers/extdrv/: flash_opt.c gnss.c IOI2C.c led.c MMA845X.c sim900.c watch_dog.c gpio.c
  group Application
    ./applications/: application.c ppp_service.c startup.c isp_process_xmpp.c ledctrlapp.c
target rtthread-stm32-EASYIO_BOARD_2 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: as above
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,EASYIO_BOARD_2
  c include: .;..\..\components\CMSIS\Include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\init;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\STM32F10x_StdPeriph_Driver\inc;..\easyio_core;drivers;..\..\components\net\lwip\src\include;..\..\components\net\lwip;..\..\components\net\lwip\src;..\..\components\net\lwip\src\arch\include;..\..\components\net\lwip\src\include\ipv4;..\..\components\net\lwip\src\include\netif;..\easyio_core\nmealib\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
target rtthread-stm32-EASYIO_UBLOX_U2 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: as above
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,EASYIO_UBLOX_U2,ENABLE_OTA
  c include: as above
  memory RVCT4: ROM 0x8004000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
